# Keil uVision project G0001-FLM.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32G0001A1TC MindMotion
  pack: MindMotion.MM32G0001_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32G0001_16
  AfterMake: fromelf --elf --output=.\Objects\MM32G0001_16.FLM .\Objects\MM32G0001_16.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --apcs=interwork --split_sections
  c include: .\APP;..\G0001-FLM;.\Device\CMSIS\Core\Include;.\Device\MM32G0001\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --no_remove
  group Flash
    ./: FlashDev.c FlashPrg.c
