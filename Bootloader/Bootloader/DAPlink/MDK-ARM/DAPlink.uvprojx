# Keil uVision project DAPlink.uvprojx, settings and files
target DAPlink (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DAPlink +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD,LCD_BAREMETAL
  c misc: --c99
  c include: ..\inc;..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\class\device\hid\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\class\device\msc\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\class\device\cdc\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\class\device\hidmsccdc;..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\device\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\usbd\Include;..\..\GD32F10x_Firmware_Library\CMSIS;..\..\USER\BSP;..\..\USER\APP;..\..\USER\FATFS;..\..\USER\IAP;..\..\..\..\GD32-HID\GD32-HID\USER\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../src/: main.c gd32f10x_it.c gd32f10x_usbd_hw.c
    ../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group USBD_Drivers
    ../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/class/device/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c usbd_msc_mem.c
  group USER/Bsp
    ../../USER/BSP/: bsp_led.c bsp_key.c bsp_oled.c bsp_gd25qxx.c bsp_pwr.c
    ../../../../GD32-HID/GD32-HID/USER/BSP/: bsp_lcd.c bsp_spi0_bus.c
  group USER/App
    ../../USER/APP/: run.c
  group USER/Iap
    ../../USER/IAP/: flash.c iap.c
  group FATFS
    ../../USER/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
software components: CMSIS:CORE 5.4.0
